# Keil uVision project pwm_led_irqChangeSequence.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\..\my_helper_functions
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
